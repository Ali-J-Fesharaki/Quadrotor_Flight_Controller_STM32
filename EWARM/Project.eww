<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\pwm for armichair.ewp</path>
  </project>
  <batchBuild />
</workspace>
